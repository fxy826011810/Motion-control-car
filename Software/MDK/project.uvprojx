# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40XX,USE_STDPERIPH_DRIVER
  c include: ..\Program\Core;..\Program\Library\inc;..\Program\System;..\Program\User;..\Program\Task
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group System
    ../Program/System/: system_stm32f4xx.c stm32f4xx_it.c
  group Startup
    ../Program/Startup/: startup_stm32f40xx.s
  group Src
    ../Program/Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dac.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Task
    ../Program/Task/: cailback.c control.c
  group Driver
    ../Program/User/: delay.c dma.c gpio.c nvic.c tim.c usart.c common.c monitor.c debug.c pid.c can.c dbus.c
  group User
    ../Program/User/: main.c config.h main.h
